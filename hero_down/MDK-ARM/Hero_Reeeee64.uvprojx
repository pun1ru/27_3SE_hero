# Keil uVision project Hero_Reeeee64.uvprojx, settings and files
target Hero_Reeeee64 (6190000::V6.19::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Hero_Reeeee64 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Tasks/Inc;../GeneralHeader;../PrivateDrivers/CAN;../PrivateDrivers/DT7;../PrivateApplications/Algorism;../PrivateApplications/PID;../PrivateDrivers/CBoardIMU;../PrivateApplications/kalman_filter;../PrivateApplications/IMU_solver;../PrivateDrivers/LK;../PrivateDrivers/WheelTecIMU;../PrivateDrivers/WT901IMU;../PrivateApplications/judge_rec;../PrivateApplications/ADRC;../PrivateDrivers/DMJ4310;../PrivateApplications/UI_operation;../PrivateApplications/Song;../PrivateApplications/superSee;../PrivateDrivers/DWT;../PrivateDrivers/WS2812;../PrivateApplications/Music;../PrivateApplications/LvBo;../PrivateApplications/Shoot_Speed_contrl;../PrivateDrivers/DM-IMU;../PrivateDrivers/VT13A;..\PrivateApplications\MainControl;..\PrivateDrivers\MIT;..\qp;..\qp\qm;..\qp\qpc\include;..\qp\qpc\ports;..\qp\qpc\src
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Users/GeneralHeaders
    ../Tasks/Inc/: general_task_include.h
    ../GeneralHeader/: general_config_label.h general_define.h
    ../PrivateApplications/Song/: song.h
  group Users/Tasks
    ../Tasks/Src/: initial_task.c state_task.c peripheral_transmit_task.c peripheral_receive_task.c music_task.c task_control.c task_decision.c task_estimate.c
    ../Tasks/Inc/: state_task.h peripheral_transmit_task.h peripheral_receive_task.h music_task.h task_control.h task_decision.h task_estimate.h
  group Users/PrivateDrivers/CAN
    ../PrivateDrivers/CAN/: CAN_driver.h CAN_driver.c
  group Users/PrivateDrivers/DMJ4310
    ../PrivateDrivers/DMJ4310/: DMJ4310.h DMJ4310.c
  group Users/PrivateApplications/LK
    ../PrivateApplications/LK/: LK_driver.c LK_driver.h
    ../PrivateDrivers/LK/: LK_485_driver.c LK_485_driver.h
  group Users/PrivateDrivers/Remote
    ../PrivateDrivers/DT7/: dt7_remote_driver.h dt7_remote_driver.c
    ../PrivateDrivers/VT13A/: VT13_rc_ctrl.c VT13_rc_ctrl.h CRC.c
  group Users/PrivateDrivers/CBoardIMU
    ../PrivateDrivers/CBoardIMU/: bmi088_reg.h bmi088_middleware.h bmi088_driver.h bmi088_middleware.c bmi088_driver.c imu_temp_ctrl.c
  group Users/PrivateDrivers/DM-IMU
    ../PrivateDrivers/DM-IMU/: dm_imu.c dm_imu.h
  group Users/PrivateDrivers/WS2812
    ../PrivateApplications/IMU_solver/: ekf_quaternion.h
    ../PrivateDrivers/WS2812/: WS2812.c WS2812.h
  group Users/PrivateApplications/Math
    ../PrivateApplications/Algorism/: algorism.h algorism.c arm_matrix.h rotation_Martix.h
  group Users/PrivateApplications/Control
    ../PrivateApplications/PID/: pid.h pid.c
    ../PrivateApplications/kalman_filter/: kalman_filter.h kalman_filter.c
    ../PrivateApplications/ADRC/: adrc.h adrc.c
  group Users/PrivateApplications/IMUSolver
    ../PrivateApplications/IMU_solver/: ekf_quaternion.c ekf_imu_solver.h ekf_imu_solver.c
    ../PrivateDrivers/DWT/: bsp_dwt.c bsp_dwt.h
  group Users/PrivateApplications/judge_receive
    ../PrivateApplications/judge_rec/: judge_receive.h judge_receive.c
  group User/PrivateApplications/superSee
    ../PrivateApplications/superSee/: distance_check.c distance_check.h distance_mearsure.c distance_measure.h
  group UI
    ../PrivateApplications/UI_operation/: UI_driver.c UI_design.c UI_design.h UI_driver.h
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c iwdg.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group User/PrivateApplications/Music
    ../PrivateApplications/Music/: music_mardio.c music_mardio.h
  group Users/PrivateApplications/Notch_filter
    ../PrivateApplications/LvBo/: Notch_filter.c Notch_filter.h
  group Users/PrivateApplications/Shoot_Speed_contrl
    ../PrivateApplications/Shoot_Speed_contrl/: shoot_speed_best_contrl.c shoot_speed_best_contrl.h
  group Users/PrivateApllications/MainControl
    ../PrivateApplications/MainControl/: jointControl.c jointControl.h gimbalControl.c gimbalControl.h chassisControl.c chassisControl.h stirControl.c stirControl.h
  group Users/PrivateDrivers/MIT
    ../PrivateDrivers/MIT/: MIT.c MIT.h
  group Users/PrivateDrivers/Board2Board
    ../PrivateDrivers/Board2Borad/: Board2Board.c Board2Board.h
  group qp/qpc/include
    ../qp/qpc/include/: qequeue.h qmpool.h qp.h qp_pkg.h qpc.h qs_dummy.h qsafe.h qstamp.h
  group qp/qpc/ports
    ../qp/qpc/ports/: qf_port.c qp_port.h qs_port.h syscalls.c
  group qp/qpc/src
    ../qp/qpc/src/: qep_hsm.c qep_msm.c qf_act.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qmact.c qf_time.c qf_qeq.c
  group qp/qm
    ../qp/qm/: decision.c decision.h
  group qp
    ../qp/: qpc_init.h qp_config.h qpc_init.c
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2
